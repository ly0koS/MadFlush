# Keil uVision project Flush.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: Flush +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Flush
  group Source Group 1
    ./: STARTUP.A51 DISP.c Func.c IIC.c main.c DISP.h
